options:
  parameters:
    author: Daniel Estevez, Timothy Wriglesworth
    category: Custom
    description: Reaktor Hello World decoder
    generate_options: qt_gui
    id: openlst_satellite
    output_language: python
    title: Reaktor Hello World decoder
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '''11010011100100011101001110010001'''
  states: {}
- name: gain_mu
  id: variable
  parameters:
    value: 0.175*3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: invert
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    comment: '32767.0'
    scale: '1'
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    comment: if using streamer flowgraph for an input, change the output data type
    eof: 'False'
    ipaddr: 127.0.0.1
    port: port
    psize: '1472'
    type: float
    vlen: '1'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    comment: |-
      block seems to be working
      use deframer after
    gain_mu: gain_mu
    gain_omega: 0.25*gain_mu*gain_mu
    mu: '0.5'
    omega: '5'
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: invert
  id: parameter
  parameters:
    label: invert the waveform (-1 to invert)
    short_id: i
    type: intx
    value: '1'
  states: {}
- name: ip
  id: parameter
  parameters:
    label: UDP listen IP
    type: str
    value: 127.0.0.1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '8000'
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '600'
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: 9k6
  states: {}
- name: pn9_scrambler_0
  id: pn9_scrambler
  parameters: {}
  states: {}
- name: port
  id: parameter
  parameters:
    label: UDP port
    type: intx
    value: '7355'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '30000'
    srate: '48000'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    marker1: '0'
    name: dots
    size: '3000'
    srate: '9600'
    style1: '0'
    type: float
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}
- name: satellites_cc11xx_packet_crop_0
  id: satellites_cc11xx_packet_crop
  parameters:
    comment: packet crop block reads the length field and crops the packet to the correct size.
    use_crc16: 'False'
  states: {}
- name: satellites_cc11xx_remove_length_0
  id: satellites_cc11xx_remove_length
  parameters:
    comment: remove length field
  states: {state: disabled}
- name: satellites_check_cc11xx_crc_0
  id: satellites_check_cc11xx_crc
  parameters: {}
  states: {state: disabled}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: sync_to_pdu_packed_0
  id: sync_to_pdu_packed
  parameters:
    packlen: '255'
    sync: access_code
    threshold: threshold
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.2:5559
    timeout: '100'
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [blocks_short_to_float_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_udp_source_0, '0', blocks_short_to_float_0, '0']
- [blocks_udp_source_0, '0', blocks_throttle_0, '0']
- [digital_binary_slicer_fb_0, '0', sync_to_pdu_packed_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_time_sink_x_1, '0']
- [low_pass_filter_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [pn9_scrambler_0, out, satellites_cc11xx_packet_crop_0, in]
- [satellites_cc11xx_packet_crop_0, out, satellites_check_cc11xx_crc_0, in]
- [satellites_cc11xx_packet_crop_0, out, satellites_print_timestamp_0, in]
- [satellites_cc11xx_remove_length_0, out, satellites_print_timestamp_0, in]
- [satellites_check_cc11xx_crc_0, ok, satellites_cc11xx_remove_length_0, in]
- [satellites_print_timestamp_0, out, blocks_message_debug_0, print_pdu]
- [satellites_print_timestamp_0, out, zeromq_pub_msg_sink_0, in]
- [sync_to_pdu_packed_0, out, pn9_scrambler_0, in]

metadata:
  file_format: 1
