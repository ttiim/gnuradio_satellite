options:
  parameters:
    author: t-wrig
    generate_options: qt_gui
    id: grc_cc1110_USRP_sender
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '"11010011100100011101001110010001"'
  states: {}
- name: bit_per_sym
  id: variable
  parameters:
    value: '1'
  states: {}
- name: data_rate_tx
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: freq
    orient: Qt.Horizontal
    start: '436000000'
    step: '1'
    stop: '438000000'
    value: '437025000'
  states: {}
- name: gain_mu
  id: variable
  parameters:
    value: 0.175*3
  states: {}
- name: iq_samples_per_symbol
  id: variable
  parameters:
    value: '5'
  states: {}
- name: myqueue_in
  id: variable
  parameters:
    value: gr.msg_queue(2)
  states: {}
- name: packlen
  id: variable
  parameters:
    value: '10'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '"10101010101010101010101010101010"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate_iq
  id: variable
  parameters:
    comment: must be integer number, that i'm fairly certain about
    value: 2e6
  states: {}
- name: samp_rate_tx
  id: variable
  parameters:
    value: data_rate_tx*iq_samples_per_symbol
  states: {}
- name: synclen
  id: variable
  parameters:
    value: packlen+3
  states: {}
- name: tap
  id: variable_low_pass_filter_taps
  parameters:
    comment: |-
      2e6/40 = 50khz= ~48khz
      cutoff_f < 50e3/2 (Nyquist)
    cutoff_freq: 1e6
    gain: '1.0'
    samp_rate: 8e6
    width: 250e3
    win: firdes.WIN_HAMMING
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    comment: |-
      2e6/40 = 50khz= ~48khz
      cutoff_f < 50e3/2 (Nyquist)
    cutoff_freq: '20000'
    gain: '1.0'
    samp_rate: samp_rate_iq
    width: '2000'
    win: firdes.WIN_HAMMING
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '1'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: produce +- voltages +for 1, - for 0. Frequency demodulation.
    gain: '2'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: invert
    type: float
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: packlen
    minsize: packlen
  states: {state: disabled}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    comment: |-
      block seems to be working
      use deframer after
    gain_mu: gain_mu
    gain_omega: 0.25*gain_mu*gain_mu
    mu: '0.5'
    omega: '5'
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    comment: |-
      1 bit input procudes 20 raw i/q samples out

      The input is a byte stream (unsigned char) and the output is the complex modulated signal at baseband.
    samples_per_symbol: iq_samples_per_symbol
    sensitivity: '1'
  states: {state: disabled}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '0'
    comment: move rf to baseband, lpf, decimate
    decim: '40'
    samp_rate: samp_rate_iq
    taps: taps
  states: {}
- name: invert
  id: parameter
  parameters:
    label: invert the waveform (-1 to invert)
    short_id: i
    type: intx
    value: '1'
  states: {}
- name: ip
  id: parameter
  parameters:
    label: UDP listen IP
    type: str
    value: 127.0.0.1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: 48000/5 = 9600
    cutoff_freq: '8000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate_iq/40
    type: fir_filter_ccf
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '8000'
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '600'
    win: firdes.WIN_HAMMING
  states: {}
- name: pduadd_add_length_0
  id: pduadd_add_length
  parameters: {}
  states: {}
- name: pduadd_crc16_0
  id: pduadd_crc16
  parameters: {}
  states: {}
- name: pduadd_pdu_head_tail_0
  id: pduadd_pdu_head_tail
  parameters:
    add: preamble
  states: {}
- name: pduadd_pdu_head_tail_0_0
  id: pduadd_pdu_head_tail
  parameters:
    add: access_code
  states: {}
- name: pduadd_usrp_pad_0
  id: pduadd_usrp_pad
  parameters:
    bits_per_symbol: bit_per_sym
    samples_per_symbol: iq_samples_per_symbol
  states: {state: disabled}
- name: port
  id: parameter
  parameters:
    label: UDP port
    type: intx
    value: '7355'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate_iq
    ctrlpanel: 'True'
    fc: freq
    fftsize: '1024'
    name: '"raw"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_iq
    ctrlpanel: 'True'
    fc: freq
    fftsize: '1024'
    name: '"demod"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"mod"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_2_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"premod"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"postmodcustom"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"end"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2_1_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"ore lowpadd"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2_1_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"quad"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: satellites_cc11xx_packet_crop_0
  id: satellites_cc11xx_packet_crop
  parameters:
    comment: packet crop block reads the length field and crops the packet to the correct size.
    use_crc16: 'True'
  states: {}
- name: satellites_check_cc11xx_crc_0
  id: satellites_check_cc11xx_crc
  parameters: {}
  states: {}
- name: satellites_pn9_scrambler_0
  id: satellites_pn9_scrambler
  parameters: {}
  states: {}
- name: satellites_pn9_scrambler_0_0
  id: satellites_pn9_scrambler
  parameters: {}
  states: {}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_sync_to_pdu_packed_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '8'
    sync: access_code
    threshold: '1'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    dev_addr: '"serial=308F983"'
    dev_args: '""'
    gain0: '60'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: 2e6
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_addr: '"serial=30875ED"'
    dev_args: '""'
    gain0: '60'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: 2e6
    sync: none
    type: fc32
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5555
    bind: ''
    timeout: '100'
  states: {state: disabled}
- name: zeromq_sub_msg_source_1
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:5555
    bind: ''
    timeout: '100'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_2_1_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_2_0_0, '0']
- [blocks_char_to_float_0_0_0_0, '0', qtgui_time_sink_x_2_0_1, '0']
- [blocks_message_strobe_0, strobe, blocks_random_pdu_0, generate]
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_2_1_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', digital_gfsk_mod_0, '0']
- [blocks_random_pdu_0, pdus, pduadd_add_length_0, in]
- [blocks_throttle_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0_0_0_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_sync_to_pdu_packed_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_time_sink_x_2_1, '0']
- [digital_gfsk_mod_0, '0', analog_quadrature_demod_cf_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_freq_sink_x_1, '0']
- [digital_gfsk_mod_0, '0', qtgui_time_sink_x_2, '0']
- [digital_gfsk_mod_0, '0', uhd_usrp_sink_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [pduadd_add_length_0, out, pduadd_crc16_0, in]
- [pduadd_crc16_0, out, blocks_message_debug_0_0, print_pdu]
- [pduadd_crc16_0, out, satellites_pn9_scrambler_0, in]
- [pduadd_crc16_0, out, zeromq_pub_msg_sink_0, in]
- [pduadd_pdu_head_tail_0, out, blocks_message_debug_0, print_pdu]
- [pduadd_pdu_head_tail_0, out, blocks_pdu_to_tagged_stream_0_0, pdus]
- [pduadd_pdu_head_tail_0, out, pduadd_usrp_pad_0, in]
- [pduadd_pdu_head_tail_0_0, out, pduadd_pdu_head_tail_0, in]
- [pduadd_usrp_pad_0, out, blocks_pdu_to_tagged_stream_0_0, pdus]
- [rational_resampler_xxx_0, '0', blocks_throttle_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0_1_0, '0']
- [satellites_cc11xx_packet_crop_0, out, satellites_check_cc11xx_crc_0, in]
- [satellites_check_cc11xx_crc_0, fail, satellites_print_timestamp_0, in]
- [satellites_check_cc11xx_crc_0, ok, satellites_print_timestamp_0, in]
- [satellites_pn9_scrambler_0, out, blocks_socket_pdu_0, pdus]
- [satellites_pn9_scrambler_0, out, pduadd_pdu_head_tail_0_0, in]
- [satellites_pn9_scrambler_0_0, out, satellites_cc11xx_packet_crop_0, in]
- [satellites_print_timestamp_0, out, blocks_message_debug_0_1, print_pdu]
- [satellites_sync_to_pdu_packed_0, out, satellites_pn9_scrambler_0_0, in]
- [uhd_usrp_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [zeromq_sub_msg_source_1, out, pduadd_add_length_0, in]

metadata:
  file_format: 1
