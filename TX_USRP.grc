options:
  parameters:
    author: t-wrig
    generate_options: qt_gui
    id: grc_cc1110_USRP_sender
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '"11010011100100011101001110010001"'
  states: {}
- name: bit_per_sym
  id: variable
  parameters:
    value: '1'
  states: {}
- name: data_rate_tx
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: freq
    orient: Qt.Horizontal
    start: '436000000'
    step: '1'
    stop: '438000000'
    value: '437025000'
  states: {}
- name: iq_samples_per_symbol
  id: variable
  parameters:
    value: '20'
  states: {}
- name: myqueue_in
  id: variable
  parameters:
    value: gr.msg_queue(2)
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '"1010101010101010"'
  states: {}
- name: samp_rate_tx
  id: variable
  parameters:
    value: data_rate_tx*iq_samples_per_symbol
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_tx
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/ethan/prepdu
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      keep amplitude low, or will couple into RX port of USRP
      output will interfere with input
    const: '1'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_1
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    comment: |-
      Not sure if this is necessary
      What about USRP Pad?
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '10'
    minsize: '10'
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    comment: |-
      1 bit input procudes 20 raw i/q samples out

      The input is a byte stream (unsigned char) and the output is the complex modulated signal at baseband.
    samples_per_symbol: iq_samples_per_symbol
    sensitivity: '1.0'
  states: {state: disabled}
- name: ip
  id: parameter
  parameters:
    label: UDP listen IP
    type: str
    value: 127.0.0.1
  states: {}
- name: pduadd_add_length_0
  id: pduadd_add_length
  parameters: {}
  states: {}
- name: pduadd_crc16_0
  id: pduadd_crc16
  parameters: {}
  states: {}
- name: pduadd_pdu_head_tail_0
  id: pduadd_pdu_head_tail
  parameters:
    add: preamble
  states: {}
- name: pduadd_pdu_head_tail_0_0
  id: pduadd_pdu_head_tail
  parameters:
    add: access_code
  states: {}
- name: pduadd_usrp_pad_0
  id: pduadd_usrp_pad
  parameters:
    bits_per_symbol: bit_per_sym
    samples_per_symbol: iq_samples_per_symbol
  states: {}
- name: port
  id: parameter
  parameters:
    label: UDP port
    type: intx
    value: '7355'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '250000'
    fc: '0'
    fftsize: '1024'
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '192000'
    interp: '250000'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: satellites_pn9_scrambler_0
  id: satellites_pn9_scrambler
  parameters: {}
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    dev_addr: '"serial=308F983"'
    dev_args: '""'
    gain0: '60'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: '250000'
    sync: none
    type: fc32
  states: {state: disabled}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5555
    bind: ''
    timeout: '100'
  states: {state: disabled}
- name: zeromq_sub_msg_source_1
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:5555
    bind: ''
    timeout: '100'
  states: {state: disabled}

connections:
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [audio_source_0, '0', analog_nbfm_tx_0, '0']
- [blocks_message_strobe_0, strobe, blocks_random_pdu_0, generate]
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_packed_to_unpacked_xx_1, '0', digital_gfsk_mod_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', analog_nbfm_tx_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', blocks_file_sink_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', blocks_packed_to_unpacked_xx_1, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', blocks_tag_debug_0, '0']
- [blocks_random_pdu_0, pdus, pduadd_add_length_0, in]
- [digital_gfsk_mod_0, '0', rational_resampler_xxx_1, '0']
- [pduadd_add_length_0, out, pduadd_crc16_0, in]
- [pduadd_crc16_0, out, satellites_pn9_scrambler_0, in]
- [pduadd_crc16_0, out, zeromq_pub_msg_sink_0, in]
- [pduadd_pdu_head_tail_0, out, pduadd_usrp_pad_0, in]
- [pduadd_pdu_head_tail_0_0, out, pduadd_pdu_head_tail_0, in]
- [pduadd_usrp_pad_0, out, blocks_message_debug_0, print_pdu]
- [pduadd_usrp_pad_0, out, blocks_pdu_to_tagged_stream_0_0, pdus]
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [satellites_pn9_scrambler_0, out, blocks_message_debug_0_0, print_pdu]
- [satellites_pn9_scrambler_0, out, blocks_socket_pdu_0, pdus]
- [satellites_pn9_scrambler_0, out, pduadd_pdu_head_tail_0_0, in]
- [zeromq_sub_msg_source_1, out, pduadd_add_length_0, in]

metadata:
  file_format: 1
