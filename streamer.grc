options:
  parameters:
    author: t-wrig
    generate_options: qt_gui
    id: streamer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: short
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: make sure it's 48khz, or it won't work well on decode
    file: /tmp/orcasat_hello_world.wav
    repeat: 'True'
  states: {}
- name: destination
  id: parameter
  parameters:
    label: localhost
    type: str
    value: localhost
  states: {}
- name: port
  id: parameter
  parameters:
    label: port
    type: intx
    value: '7355'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: check signal saturation level
    ctrlpanel: 'True'
    size: '50000'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: udp_stre
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: port
    psize: '1472'
    type: short
    vlen: '1'
  states: {}

connections:
- [blocks_float_to_short_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', udp_stre, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_short_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
