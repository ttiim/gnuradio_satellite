options:
  parameters:
    author: t-wrig
    generate_options: qt_gui
    id: test_wav
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '''00110101001011100011010100101110'''
  states: {state: disabled}
- name: baud_rate
  id: variable
  parameters:
    value: '9600'
  states: {state: disabled}
- name: gain_mu
  id: variable
  parameters:
    value: 0.175*3
  states: {state: disabled}
- name: samp_rate_48k
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate_iq
  id: variable
  parameters:
    value: '1800000'
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '10'
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    comment: |-
      1.8e6/40 = 45khz= ~48khz
      cutoff_f < 45e3/2 (Nyquist)
    cutoff_freq: '20000'
    gain: '1.0'
    samp_rate: samp_rate_iq
    width: '2000'
    win: firdes.WIN_HAMMING
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '4'
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      produce +- voltages +for 1, - for 0. Frequency demodulation. see cc1110 for encoding
      instanteous frequency
    gain: '2'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/t-wrig/Desktop/ORCASAT_ALEASAT/testbuffer.txt
    type: byte
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_tcp_server_sink_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: localhost
    noblock: 'True'
    port: '7355'
    type: byte
    vlen: '1'
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '1800000'
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    comment: send to decoder
    file: /tmp/dummy.wav
    samp_rate: samp_rate_48k
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/t-wrig/Desktop/future ALEASAT/recordings/SDRSharp_20201001_TYPE1_5_PACKETS_436800000Hz_IQ.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    comment: |-
      block seems to be working
      use deframer after

      cannot be " square " -> watch out for saturation +-1

      gain omega: 0.25*gain_mu*gain_mu
    gain_mu: gain_mu
    gain_omega: ' 0.25*gain_mu*gain_mu'
    mu: '0.5'
    omega: samples_per_symbol
    omega_relative_limit: '0.005'
    type: float
  states: {state: disabled}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: 0.206e6-5500-2210
    comment: |-
      move rf to baseband, lpf, decimate

      -get_telem: 0.206e6+1220


      -2360 fec


      0.206e6-3300 case1
    decim: '40'
    samp_rate: samp_rate_iq
    taps: taps
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: 48000/5 = 9600
    cutoff_freq: '8000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate_iq/40
    type: fir_filter_ccf
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: pn9_scrambler_0
  id: pn9_scrambler
  parameters: {}
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_iq/40
    comment: don't forget to BW= samp_rate_iq/40
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_iq/40
    comment: don't forget to BW= samp_rate_iq/40
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '30000'
    srate: samp_rate_48k
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    marker1: '0'
    name: dots
    size: '10000'
    srate: '9600'
    style1: '0'
    type: float
    width1: '0.5'
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '45'
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: satellites_cc11xx_packet_crop_0
  id: satellites_cc11xx_packet_crop
  parameters:
    use_crc16: 'False'
  states: {state: disabled}
- name: satellites_cc11xx_remove_length_0
  id: satellites_cc11xx_remove_length
  parameters: {}
  states: {state: disabled}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {state: disabled}
- name: sync_to_pdu_packed_0
  id: sync_to_pdu_packed
  parameters:
    comment: 'threshold : maximum number of bits that may be wrong'
    packlen: '255'
    sync: access_code
    threshold: threshold
  states: {state: disabled}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.2:5557
    timeout: '100'
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_tcp_server_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', sync_to_pdu_packed_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_time_sink_x_1, '0']
- [freq_xlating_fft_filter_ccc_0, '0', low_pass_filter_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [pn9_scrambler_0, out, satellites_cc11xx_packet_crop_0, in]
- [rational_resampler_xxx_0, '0', blocks_wavfile_sink_0, '0']
- [rational_resampler_xxx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [satellites_cc11xx_packet_crop_0, out, satellites_cc11xx_remove_length_0, in]
- [satellites_cc11xx_remove_length_0, out, satellites_print_timestamp_0, in]
- [satellites_print_timestamp_0, out, blocks_message_debug_0, print_pdu]
- [sync_to_pdu_packed_0, out, pn9_scrambler_0, in]
- [sync_to_pdu_packed_0, out, zeromq_pub_msg_sink_0, in]

metadata:
  file_format: 1
