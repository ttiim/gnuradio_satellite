options:
  parameters:
    author: t-wrig
    generate_options: qt_gui
    id: grc_cc1110_USRP_sender
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '"11010011100100011101001110010001"'
  states: {}
- name: bit_per_sym
  id: variable
  parameters:
    value: '1'
  states: {}
- name: data_rate1
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: data_rate_tx
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: gain_mu
  id: variable
  parameters:
    value: 0.175*3
  states: {}
- name: gain_muu
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '10'
    value: '0.175'
  states: {}
- name: iq_samples_per_symbol
  id: variable
  parameters:
    value: '230'
  states: {}
- name: muu
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '10'
    value: '0.5'
  states: {}
- name: num_packets1
  id: variable
  parameters:
    value: '100'
  states: {}
- name: omegalul
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '10'
    value: '0.005'
  states: {}
- name: packet_len1
  id: variable
  parameters:
    value: '50'
  states: {}
- name: packlen
  id: variable
  parameters:
    value: '5'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '"1010101010101010"'
  states: {}
- name: rfreq
  id: variable_qtgui_range
  parameters:
    label: rfreq
    orient: Qt.Horizontal
    start: '433000000'
    step: '1'
    stop: '450000000'
    value: '437025000'
  states: {}
- name: rgain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate1
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: samp_rate_iq
  id: variable
  parameters:
    comment: must be integer number, that i'm fairly certain about
    value: 2e6
  states: {}
- name: samp_rate_tx
  id: variable
  parameters:
    value: data_rate_tx*iq_samples_per_symbol
  states: {}
- name: sps1
  id: variable
  parameters:
    value: '10'
  states: {}
- name: synclen
  id: variable
  parameters:
    value: packlen+3
  states: {}
- name: tap
  id: variable_low_pass_filter_taps
  parameters:
    comment: |-
      2e6/40 = 50khz= ~48khz
      cutoff_f < 50e3/2 (Nyquist)
    cutoff_freq: 1e6
    gain: '1.0'
    samp_rate: 8e6
    width: 250e3
    win: firdes.WIN_HAMMING
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    comment: |-
      2e6/40 = 50khz= ~48khz
      cutoff_f < 50e3/2 (Nyquist)
    cutoff_freq: '20000'
    gain: '1.0'
    samp_rate: samp_rate_iq
    width: '2000'
    win: firdes.WIN_HAMMING
  states: {}
- name: tfreq
  id: variable_qtgui_range
  parameters:
    label: tfreq
    orient: Qt.Horizontal
    start: '433000000'
    step: '1'
    stop: '450000000'
    value: '437025000'
  states: {}
- name: tgain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '60'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '1'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: 8*packet_len1*num_packets1
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len1"'
    packet_len: packet_len1
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len1
    type: byte
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: data_rate1
    type: byte
  states: {}
- name: channels_phase_noise_gen_0
  id: channels_phase_noise_gen
  parameters:
    alpha: '0.1'
    noise_mag: '0'
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    comment: |-
      0.175
      0.5
      0.005
    freq_error: '0.0'
    gain_mu: gain_muu
    mu: muu
    omega_relative_limit: omegalul
    samples_per_symbol: '10'
    sensitivity: '1.0'
  states: {}
- name: digital_gfsk_demod_0_0
  id: digital_gfsk_demod
  parameters:
    comment: |-
      0.175
      0.5
      0.005
    freq_error: '0.0'
    gain_mu: gain_muu
    mu: muu
    omega_relative_limit: omegalul
    samples_per_symbol: '10'
    sensitivity: '1.0'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    comment: |-
      1 bit input procudes 20 raw i/q samples out

      The input is a byte stream (unsigned char) and the output is the complex modulated signal at baseband.
    samples_per_symbol: '10'
    sensitivity: '1'
  states: {}
- name: digital_gfsk_mod_1
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: sps1
    sensitivity: '1.0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    comment: dummy place
    example_param: ''
  states: {}
- name: invert
  id: parameter
  parameters:
    label: invert the waveform (-1 to invert)
    short_id: i
    type: intx
    value: '1'
  states: {}
- name: ip
  id: parameter
  parameters:
    label: UDP listen IP
    type: str
    value: 127.0.0.1
  states: {}
- name: pduadd_add_length_0
  id: pduadd_add_length
  parameters: {}
  states: {}
- name: pduadd_crc16_0
  id: pduadd_crc16
  parameters: {}
  states: {}
- name: pduadd_pdu_head_tail_0
  id: pduadd_pdu_head_tail
  parameters:
    add: preamble
  states: {}
- name: pduadd_pdu_head_tail_0_0
  id: pduadd_pdu_head_tail
  parameters:
    add: access_code
  states: {}
- name: pduadd_usrp_pad_0
  id: pduadd_usrp_pad
  parameters:
    bits_per_symbol: bit_per_sym
    samples_per_symbol: iq_samples_per_symbol
  states: {state: bypassed}
- name: pn9_scrambler_0
  id: pn9_scrambler
  parameters: {}
  states: {}
- name: pn9_scrambler_0_0
  id: pn9_scrambler
  parameters: {}
  states: {}
- name: port
  id: parameter
  parameters:
    label: UDP port
    type: intx
    value: '7355'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: 1e6
    ctrlpanel: 'True'
    fc: rfreq
    fftsize: '1024'
    name: '"send"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"mod"'
    size: '1024'
    srate: samp_rate_iq
    type: complex
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: sps1*data_rate1
    interp: samp_rate
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: sps1*data_rate1
    taps: ''
    type: ccc
  states: {}
- name: satellites_cc11xx_packet_crop_0
  id: satellites_cc11xx_packet_crop
  parameters:
    comment: packet crop block reads the length field and crops the packet to the correct size.
    use_crc16: 'True'
  states: {}
- name: satellites_check_cc11xx_crc_0
  id: satellites_check_cc11xx_crc
  parameters: {}
  states: {}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: sync_to_pdu_packed_0
  id: sync_to_pdu_packed
  parameters:
    comment: |-
      plug the gfsk mod into the gfsk demod and make sure 
      the 'sync and create packed pdu' length is set to your
       packet size when it has data, length field, and crc16
    packlen: synclen
    sync: access_code
    threshold: '1'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: samp_rate_iq
    center_freq0: tfreq
    dev_addr: '"serial=308F983"'
    dev_args: '""'
    gain0: tgain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate_iq
    sync: none
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: random_pdus
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: tx
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: rx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: random_pdus
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rx
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: tx
  states: {}
- name: zeromq_sub_msg_source_1
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:5555
    bind: ''
    comment: |-
      packet_tx_test.py just so i dont have to type continuously
      /gnuradio_satellites/zmq-python
    timeout: '100'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_0, '0', blocks_throttle_1, '0']
- [blocks_add_xx_0, '0', channels_phase_noise_gen_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', digital_gfsk_mod_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, virtual_sink_0, '0']
- [blocks_throttle_1, '0', blocks_pack_k_bits_bb_0, '0']
- [channels_phase_noise_gen_0, '0', virtual_sink_1_0, '0']
- [digital_gfsk_demod_0, '0', sync_to_pdu_packed_0, '0']
- [digital_gfsk_mod_0, '0', digital_gfsk_demod_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_freq_sink_x_1, '0']
- [digital_gfsk_mod_0, '0', qtgui_time_sink_x_2, '0']
- [digital_gfsk_mod_0, '0', uhd_usrp_sink_0, '0']
- [digital_gfsk_mod_1, '0', rational_resampler_xxx_0_0, '0']
- [epy_block_0, '0', digital_gfsk_mod_1, '0']
- [pduadd_add_length_0, out, pduadd_crc16_0, in]
- [pduadd_crc16_0, out, pn9_scrambler_0, in]
- [pduadd_pdu_head_tail_0, out, pduadd_usrp_pad_0, in]
- [pduadd_pdu_head_tail_0_0, out, pduadd_pdu_head_tail_0, in]
- [pduadd_usrp_pad_0, out, blocks_message_debug_0, print_pdu]
- [pduadd_usrp_pad_0, out, blocks_pdu_to_tagged_stream_0_0, pdus]
- [pn9_scrambler_0, out, pduadd_pdu_head_tail_0_0, in]
- [pn9_scrambler_0_0, out, satellites_cc11xx_packet_crop_0, in]
- [rational_resampler_xxx_0_0, '0', virtual_sink_1, '0']
- [satellites_cc11xx_packet_crop_0, out, satellites_check_cc11xx_crc_0, in]
- [satellites_check_cc11xx_crc_0, fail, satellites_print_timestamp_0, in]
- [satellites_check_cc11xx_crc_0, ok, satellites_print_timestamp_0, in]
- [satellites_print_timestamp_0, out, blocks_message_debug_0_1, print_pdu]
- [sync_to_pdu_packed_0, out, pn9_scrambler_0_0, in]
- [virtual_source_0, '0', epy_block_0, '0']
- [virtual_source_1, '0', rational_resampler_xxx_0_0_0, '0']
- [virtual_source_1_0, '0', blocks_add_xx_0, '0']
- [zeromq_sub_msg_source_1, out, blocks_message_debug_0_0, print_pdu]
- [zeromq_sub_msg_source_1, out, pduadd_add_length_0, in]

metadata:
  file_format: 1
